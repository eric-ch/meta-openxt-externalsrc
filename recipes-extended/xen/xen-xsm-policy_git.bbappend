inherit externalsrc

EXTERNALSRC = "${TOPDIR}/../openxt/xsm-policy"
# Makefile invoked directly.
EXTERNALSRC_BUILD = "${TOPDIR}/../openxt/xsm-policy"
