inherit externalsrc

EXTERNALSRC = "${TOPDIR}/../openxt/installer"
EXTERNALSRC_BUILD = "${TOPDIR}/../openxt/installer"
