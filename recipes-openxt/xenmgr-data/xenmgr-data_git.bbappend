inherit externalsrc

EXTERNALSRC = "${TOPDIR}/../openxt/toolstack-data"
EXTERNALSRC_BUILD = "${TOPDIR}/../openxt/toolstack-data"
