inherit externalsrc

EXTERNALSRC = "${TOPDIR}/../openxt/idl/rpcgen"
EXTERNALSRC_BUILD = "${TOPDIR}/../openxt/idl/rpcgen"
