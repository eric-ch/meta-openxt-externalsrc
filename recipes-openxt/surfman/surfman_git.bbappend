inherit externalsrc

EXTERNALSRC = "${TOPDIR}/../openxt/surfman/surfman"
