inherit externalsrc

EXTERNALSRC = "${TOPDIR}/../openxt/manager/upgrade-db"
EXTERNALSRC_BUILD = "${TOPDIR}/../openxt/manager/upgrade-db"
