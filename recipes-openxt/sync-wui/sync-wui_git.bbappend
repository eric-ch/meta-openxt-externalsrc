inherit externalsrc

EXTERNALSRC = "${TOPDIR}/../openxt/sync-wui"
