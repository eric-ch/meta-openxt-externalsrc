inherit externalsrc

EXTERNALSRC = "${TOPDIR}/../openxt/surfman/plugins/linuxfb"
