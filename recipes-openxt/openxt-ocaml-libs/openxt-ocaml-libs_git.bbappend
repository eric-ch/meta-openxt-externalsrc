inherit externalsrc

EXTERNALSRC = "${TOPDIR}/../openxt/toolstack"
EXTERNALSRC_BUILD = "${TOPDIR}/../openxt/toolstack"
