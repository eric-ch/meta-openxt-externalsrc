inherit externalsrc

EXTERNALSRC = "${TOPDIR}/../openxt/libxenbackend"
EXTERNALSRC_BUILD = "${TOPDIR}/../openxt/libxenbackend"
