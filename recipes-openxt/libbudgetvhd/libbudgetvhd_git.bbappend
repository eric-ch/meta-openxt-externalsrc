inherit externalsrc

EXTERNALSRC = "${TOPDIR}/../openxt/gene3fs/libbudgetvhd"
#EXTERNALSRC_BUILD = "${TOPDIR}/../openxt/gene3fs/libbudgetvhd"
