inherit externalsrc

EXTERNALSRC = "${TOPDIR}/../openxt/manager/xenmgr"
EXTERNALSRC_BUILD = "${TOPDIR}/../openxt/manager/xenmgr"
