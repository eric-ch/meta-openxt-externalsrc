inherit externalsrc

EXTERNALSRC = "${TOPDIR}/../openxt/xctools/qmp_helper"
