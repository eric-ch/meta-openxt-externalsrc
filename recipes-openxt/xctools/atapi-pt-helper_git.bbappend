inherit externalsrc

EXTERNALSRC = "${TOPDIR}/../openxt/xctools/atapi_pt_helper"
