inherit externalsrc

EXTERNALSRC = "${TOPDIR}/../openxt/xctools/audio_helper"
