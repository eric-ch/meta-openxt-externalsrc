inherit externalsrc

EXTERNALSRC = "${TOPDIR}/../openxt/xctools/varstored-watch"
EXTERNALSRC_BUILD = "${TOPDIR}/../openxt/xctools/varstored-watch"
