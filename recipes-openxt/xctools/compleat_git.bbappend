inherit externalsrc

EXTERNALSRC = "${TOPDIR}/../openxt/xctools/compleat"
EXTERNALSRC_BUILD = "${TOPDIR}/../openxt/xctools/compleat"
