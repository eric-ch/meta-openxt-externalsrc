inherit externalsrc

EXTERNALSRC = "${TOPDIR}/../openxt/xctools/xcpmd"
