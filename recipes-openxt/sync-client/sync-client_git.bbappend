inherit externalsrc

EXTERNALSRC = "${TOPDIR}/../openxt/sync-client"
EXTERNALSRC_BUILD = "${TOPDIR}/../openxt/sync-client"
