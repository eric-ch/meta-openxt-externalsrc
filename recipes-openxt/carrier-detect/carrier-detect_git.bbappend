inherit externalsrc

EXTERNALSRC = "${TOPDIR}/../openxt/xctools/carrier-detect"
