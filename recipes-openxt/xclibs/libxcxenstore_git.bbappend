inherit externalsrc

EXTERNALSRC = "${TOPDIR}/../openxt/xclibs/xcxenstore"
EXTERNALSRC_BUILD = "${TOPDIR}/../openxt/xclibs/xcxenstore"
