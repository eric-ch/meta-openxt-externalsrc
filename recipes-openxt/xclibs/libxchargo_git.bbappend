inherit externalsrc

EXTERNALSRC = "${TOPDIR}/../openxt/xclibs/xchargo"
EXTERNALSRC_BUILD = "${TOPDIR}/../openxt/xclibs/xchargo"
