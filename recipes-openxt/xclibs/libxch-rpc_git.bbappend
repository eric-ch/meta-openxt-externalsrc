inherit externalsrc

EXTERNALSRC = "${TOPDIR}/../openxt/xclibs/xch-rpc"
EXTERNALSRC_BUILD = "${TOPDIR}/../openxt/xclibs/xch-rpc"
