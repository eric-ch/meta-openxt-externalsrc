inherit externalsrc

EXTERNALSRC = "${TOPDIR}/../openxt/xclibs/xchdb"
EXTERNALSRC_BUILD = "${TOPDIR}/../openxt/xclibs/xchdb"
