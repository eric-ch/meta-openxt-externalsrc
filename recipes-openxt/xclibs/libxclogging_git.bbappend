inherit externalsrc

EXTERNALSRC = "${TOPDIR}/../openxt/xclibs/xclogging"
EXTERNALSRC_BUILD = "${TOPDIR}/../openxt/xclibs/xclogging"
