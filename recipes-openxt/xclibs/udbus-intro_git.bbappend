inherit externalsrc

EXTERNALSRC = "${TOPDIR}/../openxt/xclibs/udbus-intro"
EXTERNALSRC_BUILD = "${TOPDIR}/../openxt/xclibs/udbus-intro"
