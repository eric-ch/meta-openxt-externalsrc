inherit externalsrc

EXTERNALSRC = "${TOPDIR}/../openxt/xclibs/xchwebsocket"
EXTERNALSRC_BUILD = "${TOPDIR}/../openxt/xclibs/xchwebsocket"
