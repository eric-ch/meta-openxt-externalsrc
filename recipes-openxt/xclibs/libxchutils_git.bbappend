inherit externalsrc

EXTERNALSRC = "${TOPDIR}/../openxt/xclibs/xchutils"
EXTERNALSRC_BUILD = "${TOPDIR}/../openxt/xclibs/xchutils"
