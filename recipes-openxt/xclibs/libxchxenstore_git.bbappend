inherit externalsrc

EXTERNALSRC = "${TOPDIR}/../openxt/xclibs/xchxenstore"
EXTERNALSRC_BUILD = "${TOPDIR}/../openxt/xclibs/xchxenstore"
