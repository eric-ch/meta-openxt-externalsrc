inherit externalsrc

EXTERNALSRC = "${TOPDIR}/../openxt/xclibs/udbus"
EXTERNALSRC_BUILD = "${TOPDIR}/../openxt/xclibs/udbus"
