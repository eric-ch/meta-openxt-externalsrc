inherit externalsrc

EXTERNALSRC = "${TOPDIR}/../openxt/surfman/plugins/sample"
