inherit externalsrc

EXTERNALSRC = "${TOPDIR}/../openxt/libxcdbus"
EXTERNALSRC_BUILD = "${TOPDIR}/../openxt/libxcdbus"
