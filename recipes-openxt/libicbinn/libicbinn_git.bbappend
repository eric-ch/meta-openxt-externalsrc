inherit externalsrc

EXTERNALSRC = "${TOPDIR}/../openxt/icbinn/libicbinn"
# cproto generate prototypes in S.
EXTERNALSRC_BUILD = "${TOPDIR}/../openxt/icbinn/libicbinn"
