inherit externalsrc

EXTERNALSRC = "${TOPDIR}/../openxt/icbinn/pyicbinn"
EXTERNALSRC_BUILD = "${TOPDIR}/../openxt/icbinn/pyicbinn"
