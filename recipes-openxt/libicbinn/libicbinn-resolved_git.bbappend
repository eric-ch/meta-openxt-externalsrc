inherit externalsrc

EXTERNALSRC = "${TOPDIR}/../openxt/icbinn/libicbinn_resolved"
