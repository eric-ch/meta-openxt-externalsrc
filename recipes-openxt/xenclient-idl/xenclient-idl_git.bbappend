inherit externalsrc

EXTERNALSRC = "${TOPDIR}/../openxt/idl"
