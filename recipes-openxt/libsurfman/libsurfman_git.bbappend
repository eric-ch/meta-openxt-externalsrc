inherit externalsrc

EXTERNALSRC = "${TOPDIR}/../openxt/surfman/libsurfman"
