inherit externalsrc

EXTERNALSRC = "${TOPDIR}/../openxt/linux-xen-argo/libargo"
EXTERNALSRC_BUILD = "${TOPDIR}/../openxt/linux-xen-argo/libargo"
