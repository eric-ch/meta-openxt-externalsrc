inherit externalsrc

EXTERNALSRC = "${TOPDIR}/../openxt/network/nws"
EXTERNALSRC_BUILD = "${TOPDIR}/../openxt/network/nws"
