inherit externalsrc

EXTERNALSRC = "${TOPDIR}/../openxt/uid"
EXTERNALSRC_BUILD = "${TOPDIR}/../openxt/uid"
