inherit externalsrc

EXTERNALSRC = "${TOPDIR}/../openxt/manager/xenmgr-core"
EXTERNALSRC_BUILD = "${TOPDIR}/../openxt/manager/xenmgr-core"
