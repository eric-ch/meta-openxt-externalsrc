inherit externalsrc

EXTERNALSRC = "${TOPDIR}/../openxt/manager/xec"
EXTERNALSRC_BUILD = "${TOPDIR}/../openxt/manager/xec"
