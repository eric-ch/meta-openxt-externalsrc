inherit externalsrc

EXTERNALSRC = "${TOPDIR}/../openxt/manager/rpc-proxy"
EXTERNALSRC_BUILD = "${TOPDIR}/../openxt/manager/rpc-proxy"
