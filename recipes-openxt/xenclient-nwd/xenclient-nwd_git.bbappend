inherit externalsrc

EXTERNALSRC = "${TOPDIR}/../openxt/network/nwd"
EXTERNALSRC_BUILD = "${TOPDIR}/../openxt/network/nwd"
