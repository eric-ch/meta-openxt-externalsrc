inherit externalsrc

EXTERNALSRC = "${TOPDIR}/../openxt/libedid"
# cproto generate prototypes in S.
EXTERNALSRC_BUILD = "${TOPDIR}/../openxt/libedid"
