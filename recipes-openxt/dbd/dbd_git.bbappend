inherit externalsrc

EXTERNALSRC = "${TOPDIR}/../openxt/manager/dbd"
EXTERNALSRC_BUILD = "${TOPDIR}/../openxt/manager/dbd"
