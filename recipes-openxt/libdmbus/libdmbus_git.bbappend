inherit externalsrc

EXTERNALSRC = "${TOPDIR}/../openxt/xctools/libdmbus"
# References to srcdir for version.sed.
EXTERNALSRC_BUILD = "${TOPDIR}/../openxt/xctools/libdmbus"
