inherit externalsrc

EXTERNALSRC = "${TOPDIR}/../openxt/input"
