inherit externalsrc

EXTERNALSRC = "${TOPDIR}/../openxt/manager/updatemgr"
EXTERNALSRC_BUILD = "${TOPDIR}/../openxt/manager/updatemgr"
