inherit externalsrc

EXTERNALSRC = "${TOPDIR}/../openxt/vusb-daemon"
