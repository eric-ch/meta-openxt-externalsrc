inherit externalsrc

EXTERNALSRC = "${TOPDIR}/../openxt/bats-suite"
